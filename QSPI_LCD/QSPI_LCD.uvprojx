# Keil uVision project QSPI_LCD.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: QSPI_LCD +hex
  AfterMake: fromelf.exe --bin -o QSPI_LCD.bin ./output/QSPI_LCD.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../sdk/bundles/typical/inc;../sdk/bundles/typical/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing916;../sdk/src/Tools;../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005448 size 0x2bb8
  group APP
    ./src/: main.c drv_GC9c01.c qspi.c
  group StartUP
    ./src/: startup_ing91600.s
    ../sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: eflash.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_gpio.c peripheral_pinctrl.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_dma.c
  group Tools
    ../sdk/src/Tools/: trace.c
software components: CMSIS:CORE 4.3.0
