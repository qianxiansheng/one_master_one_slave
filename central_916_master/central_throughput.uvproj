# Keil uVision project central_throughput.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: central_throughput +hex
  AfterMake: fromelf.exe --bin -o central_throughput.bin ./output/central_throughput.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../sdk/bundles/typical/inc;../sdk/bundles/typical/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing916;../sdk/src/Tools;../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33718272 size 360448
  memory RVCT9: RAM 536892488 size 11192
  group APP
    ./src/: main.c profile.c uart_console.c
  group StartUP
    ./src/: startup_ing91600.s
    ../sdk/bundles/typical/ING9168xx/: symdefs.m
  group FWlib
    ../sdk/src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_rtc.c peripheral_pinctrl.c peripheral_gpio.c peripheral_i2c.c
  group Tools
    ../sdk/src/Tools/: ad_parser.c rf_util.c log_util.c str_util.c
