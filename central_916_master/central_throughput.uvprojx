# Keil uVision project central_throughput.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: central_throughput +hex
  AfterMake: fromelf.exe --bin -o central_throughput.bin ./output/central_throughput.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,LOG_LEVEL=0
  c include: ../sdk/bundles/typical/inc;../sdk/bundles/typical/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing916;../sdk/src/Tools;../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005448 size 0x2bb8
  group APP
    ./src/: main.c profile.c uart_console.c
  group StartUP
    ./src/: startup_ing91600.s
    ../sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: iic.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_rtc.c peripheral_pinctrl.c peripheral_gpio.c peripheral_i2c.c
  group Tools
    ../sdk/src/Tools/: ad_parser.c rf_util.c log_util.c str_util.c trace.c
software components: CMSIS:CORE 4.3.0
