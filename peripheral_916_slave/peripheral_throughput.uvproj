# Keil uVision project peripheral_throughput.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_throughput +hex
  AfterMake: fromelf.exe --bin -o peripheral_throughput.bin ./output/peripheral_throughput.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_KEYS
  c misc: --gnu
  c include: ../sdk/bundles/typical/inc;../sdk/bundles/typical/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing918;../sdk/src/Tools;../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536900792 size 35656
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../sdk/bundles/typical/ING9188xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: board.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_gpio.c peripheral_pinctrl.c
  group Tools
    ../sdk/src/Tools/: rf_util.c
