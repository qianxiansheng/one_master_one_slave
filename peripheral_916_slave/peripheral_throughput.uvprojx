# Keil uVision project peripheral_throughput.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_throughput +hex
  AfterMake: fromelf.exe --bin -o peripheral_throughput.bin ./output/peripheral_throughput.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_KEYS,LONG_RANGE
  c include: ../sdk/bundles/typical/inc;../sdk/bundles/typical/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing918;../sdk/src/Tools;../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x28000 size 0x5c000
  memory RVCT9: RAM 0x200074b8 size 0x8b48
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../sdk/bundles/typical/ING9188xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: board.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c peripheral_gpio.c
  group Tools
    ../sdk/src/Tools/: rf_util.c trace.c
software components: CMSIS:CORE 4.3.0
