# Keil uVision project peripheral_throughput.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: peripheral_throughput +hex
  AfterMake: fromelf.exe --bin -o peripheral_throughput.bin ./output/peripheral_throughput.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_KEYS
  c include: ../sdk/bundles/typical/inc;../sdk/bundles/typical/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing916;../sdk/src/Tools;../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 33718272 size 360448
  memory RVCT9: RAM 536892712 size 10968
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: board.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c peripheral_gpio.c
  group Tools
    ../sdk/src/Tools/: rf_util.c
software components: CMSIS:CORE 4.3.0
