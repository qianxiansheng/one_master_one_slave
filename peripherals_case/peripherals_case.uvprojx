# Keil uVision project peripherals_case.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: peripherals_case +hex
  AfterMake: fromelf.exe --bin -o peripherals_case.bin ./output/peripherals_case.axf
  c flags: Optim=1 OneElfS=1 v6Lang=2 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../sdk/bundles/typical/inc;../sdk/bundles/typical/inc/os;../sdk/src/BSP;../sdk/src/FWlib;../sdk/src/StartUP/ing916;../sdk/src/Tools;../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005438 size 0x2bc8
  group APP
    ./src/: main.c case_adc.c case_eflash.c case_gpio.c case_iic.c case_pwm.c case_rtc.c case_spi.c case_timer.c case_uart.c case_wdt.c pch.h
  group StartUP
    ./src/: startup_ing91600.s
    ../sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../sdk/src/BSP/: eflash.c iic.c
  group FWlib
    ../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
software components: CMSIS:CORE 4.3.0
